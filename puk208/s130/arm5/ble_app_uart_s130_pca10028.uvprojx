# Keil uVision project ble_app_uart_s130_pca10028.uvprojx, settings and files
target nrf51422_xxac_s130 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s130 +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD BOARD_PUK208 S130 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --c99
  c include: .\RTE\Board_Support\nRF51422_xxAC;..\..\..\include
  asm define: BLE_STACK_SUPPORT_REQD BOARD_PCA10028 S130 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x24000
  memory RVCT9: RAM 0x20002800 size 0x5800
  group Application
    ../../../app/: main.c app_board.c app_io.c app_ble.c app_uart_rtx.c app_accel.c app_bond_act.c app_finder.c app_link_check.c app_photo_key.c app_position.c app_proximity.c app_watch_lock.c app_settings.c
  group Documentation
    ../../../: Abstract.txt license.txt
target flash_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: as above
  output: s130_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD
  c misc: --c99
  asm define: BLE_STACK_SUPPORT_REQD
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 3.40.0, Board Support:bsp 9.0.0, Board Support:bsp_btn_ble 9.0.0, Device:Startup 7.2.1, nRF_BLE:BLE_Modules:ble_advdata 3.0.1, nRF_BLE:BLE_Modules:ble_advertising 3.0.1, nRF_BLE:BLE_Modules:ble_common 3.0.1, nRF_BLE:BLE_Modules:ble_conn_params 3.0.1, nRF_BLE:BLE_Modules:ble_service_common 3.0.1, nRF_BLE:BLE_Services:ble_nus 3.0.1, nRF_Drivers:app_uart 3.0.1, nRF_Drivers:nrf_delay 3.0.1, nRF_Drivers:nrf_drv_common 3.0.1, nRF_Drivers:nrf_drv_gpiote 3.0.1, nRF_Drivers:nrf_error 3.0.1, nRF_Drivers:nrf_gpio 3.0.1, nRF_Drivers:nrf_gpiote 3.0.1, nRF_Drivers:pstorage 3.0.1, nRF_Libraries:app_button 3.0.1, nRF_Libraries:app_error 3.0.1, nRF_Libraries:app_fifo 3.0.1, nRF_Libraries:app_timer 3.0.1, nRF_Libraries:app_trace 3.0.1, nRF_Libraries:app_util 3.0.1, nRF_Libraries:nrf_assert 3.0.1, nRF_Libraries:retarget 3.0.1, nRF_SoftDevice:Internal:sd_common 1.1.4, nRF_SoftDevice:Internal:softdevice_present 1.1.4, nRF_SoftDevice:s130 1.0.1, nRF_SoftDevice:s130_hex 1.0.1, nRF_SoftDevice:softdevice_hex 1.1.4
